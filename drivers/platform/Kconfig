## drivers/platform/Kconfig
```kconfig
if X86
source "drivers/platform/x86/Kconfig"
endif

if FSL_SOC
source "drivers/platform/fsl/Kconfig"
endif
```
